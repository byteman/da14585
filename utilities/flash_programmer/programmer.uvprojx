# Keil uVision project programmer.uvprojx, settings and files
target programmer_jtag (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: jtag_programmer +hex
  AfterMake: fromelf --bincombined --output=".\Out_jtag\@L.bin"  "!L"
  c flags: Optim=4
  c misc: --c99 --thumb -c --bss_threshold=0
  c include: .\..\..\sdk\platform\driver\i2c_eeprom;.\..\..\sdk\platform\driver\spi;.\..\..\sdk\platform\arch;.\..\..\sdk\platform\arch\compiler\rvds;.\..\..\sdk\platform\arch\ll\rvds;.\..\..\sdk\platform\driver\reg;.\..\..\sdk\platform\include;.\include;.\..\..\sdk\platform\driver\gpio;.\..\..\sdk\platform\driver\spi_flash;.\..\..\sdk\app_modules\api;.\..\..\sdk\ble_stack\rwble_hl;.\..\..\sdk\ble_stack\rwble;.\..\..\sdk\platform\core_modules\rwip\api;.\..\..\sdk\platform\driver\hw_otpc
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x1b00
  memory RVCT9: RAM 0x81b00 size 0x500
  scatter file: .\startup\bootloader_jtag.sct
  link misc: --datacompressor=off
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group Source Files
    ./src/: peripherals.c uart.c programmer.c
    ../../third_party/crc32/: crc32.c
    ./../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ./../../sdk/platform/driver/spi_flash/: spi_flash.c
    ./../../sdk/platform/driver/spi/: spi.c
    ./../../sdk/platform/driver/gpio/: gpio.c
    ../../sdk/platform/driver/hw_otpc/: hw_otpc.c
  group Include Files
    ./include/: peripherals.h user_periph_setup.h uart.h programmer.h version.h
    ./../../sdk/platform/driver/gpio/: gpio.h
    ./../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ./../../sdk/platform/driver/spi/: spi.h
    ./../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../sdk/platform/driver/hw_otpc/: hw_otpc.h
target programmer_uart (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: flash_programmer +hex
  AfterMake: fromelf --bincombined --output=".\Out_uart\@L.bin"  "!L"
  c flags: Optim=4
  c define: USE_UART
  c misc: --c99 --thumb -c --bss_threshold=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xa000
  scatter file: .\startup\bootloader_uart.sct
  link misc: --datacompressor=off
