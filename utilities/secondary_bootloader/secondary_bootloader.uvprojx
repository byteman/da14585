# Keil uVision project secondary_bootloader.uvprojx, settings and files
target secondary_bootloader_585 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: secondary_bootloader_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_585\@L.bin"  "!L"
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: .\includes;..\..\sdk\platform\include;..\..\sdk\platform\driver\spi;..\..\sdk\platform\driver\i2c_eeprom;..\..\sdk\platform\driver\spi_flash;..\..\sdk\platform\driver\gpio;..\..\sdk\platform\arch;..\..\sdk\platform\arch\compiler\rvds;..\..\sdk\platform\arch\ll\rvds;..\..\sdk\platform\driver\reg
  asm include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader.sct
  group boot
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group src
    ./src/: bootloader.c timer.c uart.c main.c uart_booter.c spi_commands.c sw_aes.c decrypt.c
    ../../sdk/platform/driver/spi_flash/: spi_flash.c
    ../../sdk/platform/driver/spi/: spi.c
    ../../sdk/platform/driver/gpio/: gpio.c
    ../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../third_party/crc32/: crc32.c
  group includes
    ./includes/: user_periph_setup.h timer.h uart.h uart_booter.h bootloader.h spi_commands.h os_int.h os_port.h sw_aes.h
    ../../sdk/platform/include/: datasheet.h
    ../../sdk/platform/driver/spi/: spi.h
    ../../sdk/platform/driver/spi_flash/: spi_flash.h
    ../../sdk/platform/driver/gpio/: gpio.h
    ../../sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
target secondary_bootloader_586 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: secondary_bootloader_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_586\@L.bin"  "!L"
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: __DA14586__
  c misc: --c99
  c include: as above
  asm include: .\includes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\bootloader.sct
